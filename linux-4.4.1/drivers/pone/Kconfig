## linux-4.4.1/mm/pone/Kconfig
```kconfig
menu "page dynamic support"
config PONE_MODULE
        bool "page one merge(host)"
config PPR_MODULE
		bool "free page reclaim(guest)"
endmenu
```
